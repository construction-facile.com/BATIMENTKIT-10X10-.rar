Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: Tekla.ifc
Time: 2022-11-17T09:27:55
Author: RV-PC\W77
Organization: Structural Designer
Written by: IFC Database version:Work
Made in: Tekla Structures 21.1, IFC Export Version: 4.0.0.0 Sep 11 2015

# IfcSite, Undefined
RefElevation: 0 mm

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: PL2*400 (24)
In: Undefined
Description: PL2*400; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: CO0(?); Repère d'assemblage: CO0(?); Phase: 1; Classe: 99; Matériau: S235JR; Profil: PL2*400; Nom: CORNIERE
Tekla Quantités - Poids: 0.6 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 130.4 m2; Surface nette: 0.1 m2; Hauteur: 400 mm; Largeur: 2 mm; Longueur: 106 mm
Pset_BeamCommon - LoadBearing: yes; Reference: CO0(?)
BaseQuantities - Length: 106 mm; OuterSurfaceArea: 0.088432 m2; NetVolume: 0.0000864 m3; NetWeight: 0.67824 kg
Name | Niveau bas | Niveau haut
8 x CORNIERE | +4.276 | +4.679
8 x CORNIERE | +2.054 | +2.104
8 x CORNIERE | +0.179 | +0.229

# IfcBeam: PL4*105 (5)
In: Undefined
Description: PL4*105; Material: STEEL/S235JR
Pset_BeamCommon - LoadBearing: yes; Reference: AT0(?)
Tekla Commun - Repère de pièce: AT0(?); Repère d'assemblage: AT0(?); Phase: 56; Classe: 3; Matériau: S235JR; Profil: PL4*105; Nom: ATTACHE
Tekla Quantités - Poids: 1 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 67 m2; Surface nette: 0.1 m2; Hauteur: 105 mm; Largeur: 4 mm; Longueur: 290 mm
BaseQuantities - Length: 289.983 mm; OuterSurfaceArea: 0.0649283 m2; NetVolume: 0.000123473 m3; NetWeight: 0.969263 kg
Name | Niveau bas | Niveau haut
2 x ATTACHE | +4.874 | +4.985
2 x ATTACHE | +4.138 | +4.249
ATTACHE | +4.514 | +4.624

# IfcBeam: PL4*150 (16)
In: Undefined
Description: PL4*150; Material: STEEL/Steel_Undefined
Tekla Commun - Repère de pièce: A0(?); Repère d'assemblage: A0(?); Matériau: Steel_Undefined; Profil: PL4*150; Nom: AT CROIX
Tekla Quantités - Poids: 2.9 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 65.8 m2; Surface nette: 0.2 m2; Hauteur: 150 mm; Largeur: 4 mm; Longueur: 602 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A0(?)
BaseQuantities - Length: 602 mm; OuterSurfaceArea: 0.18908 m2; NetVolume: 0.000366 m3; NetWeight: 2.8731 kg
Name | Niveau bas | Niveau haut | Phase | Classe
4 x AT CROIX | +0.344 | +0.494 | 265 | 99
4 x AT CROIX | +3.704 | +3.854 | 265 | 99
4 x AT CROIX | +4.592 | +4.823 | 264 | 6
2 x AT CROIX | +3.899 | +4.130 | 264 | 6
2 x AT CROIX | +3.895 | +4.126 | 264 | 6

# IfcBeam: PL4*180 (8)
In: Undefined
Description: PL4*180; Material: STEEL/S235JR
Pset_BeamCommon - LoadBearing: yes
Tekla Commun - Phase: 258; Classe: 99; Matériau: S235JR; Profil: PL4*180
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 180 mm; Largeur: 4 mm
Name | Reference = Repère de pièce = Repère d'assemblage | Niveau bas | Niveau haut | Nom | Poids (kg) | Surface par tonne (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x PLATINE | PL0(?) | +0.000 | +0.102 | PLATINE | 1 | 66.6 | 166 | 166 | 0.064 | 0.0001224 | 0.96084
2 x ATTACHE | AT0(?) | +4.146 | +4.249 | ATTACHE | 0.8 | 67 | 131.6 | 131.569 | 0.05112 | 0.0000972 | 0.76302
2 x ATTACHE | AT0(?) | +4.446 | +4.549 | ATTACHE | 0.8 | 67 | 131.6 | 131.569 | 0.05112 | 0.0000972 | 0.76302

# IfcBeam: PL4*200 (70)
In: Undefined
Description: PL4*200; Material: STEEL/S235JR
Tekla Commun - Classe: 99; Matériau: S235JR; Profil: PL4*200
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 200 mm; Largeur: 4 mm
Pset_BeamCommon - LoadBearing: yes
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Phase | Nom | Poids (kg) | Surface par tonne (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
10 x PLATINE | +0.137 | +0.179 | PL0(?) | 252 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
6 x PLATINE | +2.062 | +2.104 | PL0(?) | 252 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
12 x PLATINE | +3.512 | +3.554 | PL0(?) | 252 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
3 x PLATINE | +2.637 | +2.679 | PL0(?) | 252 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
4 x PLATINE | +2.063 | +2.105 | PL0(?) | 252 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
6 x ATTACHE | +4.098 | +4.303 | AT0(?) | 59 | ATTACHE | 1.2 | 66.3 | 0.1 | 190 | 190.013 | 0.0807574 | 0.000155211 | 1.2184
6 x ATTACHE | +4.834 | +5.039 | AT0(?) | 59 | ATTACHE | 1.2 | 66.3 | 0.1 | 190 | 190.013 | 0.0807574 | 0.000155211 | 1.2184
8 x ATTACHE | +3.909 | +3.956 | AT0(?) | 65 | ATTACHE | 1.2 | 66.3 | 0.1 | 205 | 205.003 | 0.0868733 | 0.000167203 | 1.31254
2 x ATTACHE | +4.098 | +4.303 | AT0(?) | 3 | ATTACHE | 1.2 | 66.3 | 0.1 | 190 | 189.993 | 0.0807492 | 0.000155195 | 1.21828
2 x PLATINE | +1.154 | +1.206 | PL0(?) | 252 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
2 x PLATINE | +2.053 | +2.105 | PL0(?) | 252 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
2 x PLATINE | +1.012 | +1.054 | PL0(?) | 252 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
2 x PLATINE | +2.889 | +2.931 | PL0(?) | 252 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
PLATINE | +2.063 | +2.105 | PL0(?) | 262 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
PLATINE | +0.000 | +0.102 | PL0(?) | 252 | PLATINE | 0.8 | 66.6 | 0.1 | 146 | 146 | 0.0628 | 0.00012 | 0.942
ATTACHE | +1.332 | +1.379 | AT0(?) | 252 | ATTACHE | 1.2 | 66.3 | 0.1 | 205 | 205.003 | 0.0868733 | 0.000167203 | 1.31254
ATTACHE | +2.632 | +2.679 | AT0(?) | 262 | ATTACHE | 1.2 | 66.3 | 0.1 | 209 | 209.003 | 0.0885053 | 0.000170403 | 1.33766
ATTACHE | +0.632 | +0.679 | AT0(?) | 262 | ATTACHE | 1.2 | 66.3 | 0.1 | 209 | 209.003 | 0.0885053 | 0.000170403 | 1.33766

# IfcBeam: PL4*250 (14)
In: Undefined
Description: PL4*250; Material: STEEL/S235JR
Pset_BeamCommon - LoadBearing: yes; Reference: CO0(?)
Tekla Commun - Niveau bas: +0.000; Niveau haut: +0.054; Repère de pièce: CO0(?); Repère d'assemblage: CO0(?); Classe: 99; Matériau: S235JR; Profil: PL4*250; Nom: CORNIERE
Tekla Quantités - Poids: 0.8 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 67.2 m2; Surface nette: 0.1 m2; Hauteur: 250 mm; Largeur: 4 mm; Longueur: 100 mm
BaseQuantities - Length: 100 mm; OuterSurfaceArea: 0.054832 m2; NetVolume: 0.000104 m3; NetWeight: 0.8164 kg
Name | Phase
12 x CORNIERE | 262
2 x CORNIERE | 65

# IfcBeam: SADEF-C+200X1.50 (53)
In: Undefined
Description: SADEF-C+200X1.50
Tekla Commun - Profil: SADEF-C+200X1.50
Tekla Quantités - Volume: 0 m3; Surface par tonne: 151.5 m2; Hauteur: 200 mm; Largeur: 100 mm
Pset_BeamCommon - LoadBearing: yes
Name | Material | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Phase | Classe | Matériau | Nom | Poids (kg) | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
LISSE | STEEL/S235JR | +0.179 | +0.279 | LS0(?) | 248 | 14 | S235JR | LISSE | 17 | 0.3 | 3 | 2990 | 2990.01 | 2.57141 | 0.00226044 | 17.7445
LISSE | STEEL/S235JR | +0.179 | +0.279 | LS0(?) | 248 | 14 | S235JR | LISSE | 21.9 | 0.3 | 3.9 | 3862.7 | 3862.69 | 3.32191 | 0.00292019 | 22.9235
LISSE | STEEL/S235JR | +2.104 | +2.204 | LS0(?) | 248 | 14 | S235JR | LISSE | 17 | 0.3 | 3 | 2990 | 2990.01 | 2.57141 | 0.00226044 | 17.7445
LISSE | STEEL/S235JR | +2.104 | +2.204 | LS0(?) | 248 | 14 | S235JR | LISSE | 21.9 | 0.3 | 3.9 | 3862.7 | 3862.69 | 3.32191 | 0.00292019 | 22.9235
2 x LISSE | STEEL/S235JR | +0.179 | +0.279 | LS0(?) | 262 | 14 | S235JR | LISSE | 10.9 | 0.2 | 1.9 | 1917.3 | 1917.3 | 1.64888 | 0.00144948 | 11.3784
2 x LISSE | STEEL/S235JR | +3.554 | +3.654 | LS0(?) | 248 | 14 | S235JR | LISSE | 17 | 0.3 | 3 | 2990 | 2990.01 | 2.57141 | 0.00226044 | 17.7445
2 x LISSE | STEEL/S235JR | +3.554 | +3.654 | LS0(?) | 248 | 14 | S235JR | LISSE | 21.9 | 0.3 | 3.9 | 3862.7 | 3862.69 | 3.32191 | 0.00292019 | 22.9235
2 x LISSE | STEEL/S235JR | +2.104 | +2.204 | LS0(?) | 262 | 14 | S235JR | LISSE | 10.9 | 0.2 | 1.9 | 1917.3 | 1917.3 | 1.64888 | 0.00144948 | 11.3784
2 x LISSE | STEEL/S235JR | +3.554 | +3.654 | LS0(?) | 248 | 14 | S235JR | LISSE | 10.9 | 0.2 | 1.9 | 1917.3 | 1917.3 | 1.64888 | 0.00144948 | 11.3784
2 x LISSE | STEEL/S235JR | +4.083 | +4.296 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.1 | 0 | 4.8 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
2 x LISSE | STEEL/S235JR | +4.819 | +5.032 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.1 | 0 | 4.8 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
2 x LISSE | STEEL/S235JR | +4.458 | +4.671 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.1 | 0 | 4.8 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
2 x LISSE | STEEL/S235JR | +3.956 | +4.056 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.1 | 0.3 | 4.8 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
2 x LISSE | STEEL/S235JR | +2.104 | +2.204 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.1 | 0.3 | 4.8 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
2 x LISSE | STEEL/S235JR | +0.229 | +0.329 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.1 | 0.3 | 4.8 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
2 x ARBA | STEEL/Steel_Undefined | +3.905 | +4.457 | A0(?) | 1 | 6 | Steel_Undefined | ARBA | 18.3 | 0 | 3.3 | 3221.9 | 3221.91 | 2.77085 | 0.00243577 | 19.1208
2 x ARBA | STEEL/Steel_Undefined | +4.261 | +4.815 | A0(?) | 1 | 6 | Steel_Undefined | ARBA | 18.4 | 0 | 3.3 | 3235.9 | 3235.94 | 2.78291 | 0.00244637 | 19.204
2 x ARBA | STEEL/Steel_Undefined | +3.903 | +4.814 | A0(?) | 1 | 6 | Steel_Undefined | ARBA | 37.3 | 0 | 6.7 | 6577.7 | 6577.69 | 5.65682 | 0.00497274 | 39.036
2 x PANNE | STEEL/S235JR | +4.083 | +4.296 | PA0(?) | 3 | 5 | S235JR | PANNE | 27.7 | 0 | 4.8 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727
2 x PANNE | STEEL/S235JR | +4.819 | +5.032 | PA0(?) | 3 | 5 | S235JR | PANNE | 27.7 | 0 | 4.8 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727
2 x PANNE | STEEL/S235JR | +4.458 | +4.671 | PA0(?) | 3 | 5 | S235JR | PANNE | 27.7 | 0 | 4.8 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727
2 x LISSE | STEEL/S235JR | +0.229 | +0.329 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.7 | 0.3 | 4.8 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727
2 x LISSE | STEEL/S235JR | +2.104 | +2.204 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.7 | 0.3 | 4.8 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727
2 x LISSE | STEEL/S235JR | +3.956 | +4.056 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.7 | 0.3 | 4.8 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727
LISSE | STEEL/S235JR | +1.054 | +1.154 | LS0(?) | 262 | 14 | S235JR | LISSE | 16.2 | 0.6 | 3 | 2862.7 | 2862.72 | 2.46194 | 0.00216422 | 16.9891
LISSE | STEEL/S235JR | +0.179 | +0.279 | LS0(?) | 262 | 14 | S235JR | LISSE | 16.2 | 0.2 | 3 | 2862.7 | 2862.72 | 2.46194 | 0.00216422 | 16.9891
LISSE | STEEL/S235JR | +1.159 | +2.100 | LS0(?) | 252 | 14 | S235JR | LISSE | 5.3 | 0 | 1 | 941 | 941 | 0.80926 | 0.000711396 | 5.58446
LISSE | STEEL/S235JR | +2.679 | +2.779 | LS0(?) | 262 | 14 | S235JR | LISSE | 17 | 0.3 | 3 | 2990 | 2990.01 | 2.57141 | 0.00226044 | 17.7445
LISSE | STEEL/S235JR | +2.789 | +2.889 | LS0(?) | 262 | 14 | S235JR | LISSE | 17 | 0.6 | 3 | 2990 | 2990.01 | 2.57141 | 0.00226044 | 17.7445
RENFORT-ATTACHE | STEEL/S235JR | +0.979 | +1.179 | RA0(?) | 261 | 99 | S235JR | RENFORT-ATTACHE | 3.4 | 0.1 | 0.6 | 600 | 600 | 0.516 | 0.0004536 | 3.56076
2 x RENFORT-ATTACHE | STEEL/S235JR | +2.279 | +2.479 | RA0(?) | 261 | 99 | S235JR | RENFORT-ATTACHE | 3.4 | 0.1 | 0.6 | 600 | 600 | 0.516 | 0.0004536 | 3.56076
LISSE | STEEL/S235JR | +2.105 | +2.205 | LS0(?) | 262 | 14 | S235JR | LISSE | 21.9 | 0.3 | 3.9 | 3860.2 | 3860.16 | 3.31974 | 0.00291828 | 22.9085

# IfcBeam: SADEF-C+200X2.00 (23)
In: Undefined
Description: SADEF-C+200X2.00; Material: STEEL/Steel_Undefined
Tekla Commun - Matériau: Steel_Undefined; Profil: SADEF-C+200X2.00
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 113.4 m2; Hauteur: 200 mm; Largeur: 100 mm
Pset_BeamCommon - LoadBearing: yes
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Phase | Classe | Nom | Poids (kg) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x POTEAU | +0.005 | +4.223 | P0(?) | 262 | 3 | POTEAU | 32 | 4.3 | 4217.9 | 4217.85 | 3.62735 | 0.00423472 | 33.2426
2 x POTEAU | +0.005 | +4.523 | P0(?) | 262 | 3 | POTEAU | 34.3 | 4.6 | 4517.6 | 4517.64 | 3.88517 | 0.00453571 | 35.6053
6 x ARBA | +3.905 | +4.836 | AB0(?) | 261 | 7 | ARBA | 36.5 | 4.8 | 4817.2 | 4817.19 | 4.14278 | 0.00483646 | 37.9662
6 x ARBA | +4.077 | +5.039 | AB0(?) | 261 | 7 | ARBA | 38.1 | 5.1 | 5023.1 | 5023.11 | 4.31987 | 0.0050432 | 39.5891
3 x POTEAU | -0.500 | +4.067 | P0(?) | 261 | 3 | POTEAU | 34.6 | 4.6 | 4567 | 4567 | 3.92762 | 0.00458527 | 35.9944
3 x POTEAU | -0.500 | +3.900 | P0(?) | 261 | 3 | POTEAU | 33.4 | 4.5 | 4400.3 | 4400.26 | 3.78422 | 0.00441786 | 34.6802
POTEAU | +0.005 | +2.100 | P0(?) | 262 | 3 | POTEAU | 15.9 | 2.1 | 2095 | 2095 | 1.8017 | 0.00210338 | 16.5115

# IfcColumn: SADEF-C+200X1.50, LISSE
In: Undefined
Description: SADEF-C+200X1.50; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +1.159; Niveau haut: +2.100; Repère de pièce: LS0(?); Repère d'assemblage: LS0(?); Phase: 252; Classe: 14; Matériau: S235JR; Profil: SADEF-C+200X1.50; Nom: LISSE
Tekla Quantités - Poids: 5.3 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 151.5 m2; Surface nette: 1 m2; Hauteur: 200 mm; Largeur: 100 mm; Longueur: 941 mm
BaseQuantities - Length: 941 mm; OuterSurfaceArea: 0.80926 m2; NetVolume: 0.000711396 m3; NetWeight: 5.58446 kg
Pset_ColumnCommon - LoadBearing: yes; Reference: LS0(?)

# IfcColumn: SADEF-C+200X2.00 (10)
In: Undefined
Description: SADEF-C+200X2.00; Material: STEEL/Steel_Undefined
Tekla Commun - Repère de pièce: P0(?); Repère d'assemblage: P0(?); Classe: 3; Matériau: Steel_Undefined; Profil: SADEF-C+200X2.00; Nom: POTEAU
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 113.4 m2; Hauteur: 200 mm; Largeur: 100 mm
Pset_ColumnCommon - LoadBearing: yes; Reference: P0(?)
Name | Niveau bas | Niveau haut | Phase | Poids (kg) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x POTEAU | +0.005 | +4.223 | 262 | 32 | 4.3 | 4217.9 | 4217.85 | 3.62735 | 0.00423472 | 33.2426
2 x POTEAU | +0.005 | +4.523 | 262 | 34.3 | 4.6 | 4517.6 | 4517.64 | 3.88517 | 0.00453571 | 35.6053
3 x POTEAU | -0.500 | +4.067 | 261 | 34.6 | 4.6 | 4567 | 4567 | 3.92762 | 0.00458527 | 35.9944
3 x POTEAU | -0.500 | +3.900 | 261 | 33.4 | 4.5 | 4400.3 | 4400.26 | 3.78422 | 0.00441786 | 34.6802

# IfcElementAssembly (271)
In: Undefined
Name | PredefinedType | Poids Assemblage/Elément béton (kg) | Niveau Bas Assemblage/Elément béton | Niveau Haut Assemblage/Elément béton | Position maillage Assemblage/Elément béton | Repère Assemblage/Elément béton | Width (mm)
2 x Steel Assembly | RIGID_FRAME | 0.6 | +0.137 | +0.179 | 5/B-C | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.6 | +0.137 | +0.179 | 5/A | PL0(?) | 52
2 x Steel Assembly | RIGID_FRAME | 0.6 | +0.137 | +0.179 | 5/D | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 17 | +0.179 | +0.279 | 5/B-D | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 21.9 | +0.179 | +0.279 | 5/A-C | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +2.062 | +2.104 | 5/B-C | PL0(?) | 52
2 x Steel Assembly | RIGID_FRAME | 0.6 | +2.062 | +2.104 | 5/D | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 17 | +2.104 | +2.204 | 5/B-D | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 21.9 | +2.104 | +2.204 | 5/A-C | LS0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 0.6 | +3.512 | +3.554 | 5/B-C | PL0(?) | 52
Steel Assembly |  | 81.4 | -0.550 | -0.000 | 5/E | S0(?) | 130
Steel Assembly |  | 1619.2 | -1.000 | -0.000 | 5/D-E | S0(?) | 800
Steel Assembly |  | 81.4 | -0.550 | -0.000 | 3/E | S0(?) | 130
Steel Assembly |  | 1619.2 | -1.000 | -0.000 | 3/D-E | S0(?) | 800
Steel Assembly |  | 81.4 | -0.550 | -0.000 | 1/E | S0(?) | 130
Steel Assembly |  | 1619.2 | -1.000 | -0.000 | 1/D-E | S0(?) | 800
Steel Assembly |  | 81.4 | -0.550 | -0.000 | 5/A | S0(?) | 130
Steel Assembly |  | 1619.2 | -1.000 | -0.000 | 5/A-B | S0(?) | 800
Steel Assembly |  | 81.4 | -0.550 | -0.000 | 3/A | S0(?) | 130
Steel Assembly |  | 1619.2 | -1.000 | -0.000 | 3/A-B | S0(?) | 800
Steel Assembly |  | 81.4 | -0.550 | -0.000 | 1/A | S0(?) | 130
Steel Assembly |  | 1619.2 | -1.000 | -0.000 | 1/A-B | S0(?) | 800
Steel Assembly | RIGID_FRAME | 0.6 | +2.637 | +2.679 | 5/D | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 1 | +0.000 | +0.102 | 5/D | PL0(?) | 72
Steel Assembly | RIGID_FRAME | 1 | +0.000 | +0.102 | 5/B-C | PL0(?) | 72
Steel Assembly | RIGID_FRAME | 0.6 | +2.063 | +2.105 | 5/A | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.6 | +3.512 | +3.554 | 5/E | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.6 | +2.063 | +2.105 | 5/B-C | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.6 | +3.512 | +3.554 | 5/A | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.6 | +0.137 | +0.179 | 5/E | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.6 | +2.062 | +2.104 | 5/E | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 10.9 | +0.179 | +0.279 | 5/D-E | LS0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 0.6 | +3.512 | +3.554 | 5/D | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 17 | +3.554 | +3.654 | 5/B-D | LS0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 32 | +0.005 | +4.223 | 5/D | P0(?) | 100
Steel Assembly | RIGID_FRAME | 0.8 | +4.146 | +4.249 | 5/D | AT0(?) | 41.8379
Steel Assembly | RIGID_FRAME | 21.9 | +3.554 | +3.654 | 5/A-C | LS0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 34.3 | +0.005 | +4.523 | 5/B-C | P0(?) | 100
Steel Assembly | RIGID_FRAME | 0.8 | +4.446 | +4.549 | 5/B-C | AT0(?) | 41.8379
Steel Assembly | RIGID_FRAME | 10.9 | +2.104 | +2.204 | 5/D-E | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 10.9 | +3.554 | +3.654 | 5/D-E | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +2.104 | +2.204 | 5/E | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.6 | +3.556 | +3.656 | 5/E | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.6 | +0.179 | +0.279 | 5/E | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.6 | +2.104 | +2.204 | 5/A | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.6 | +3.556 | +3.656 | 5/A | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.6 | +0.179 | +0.279 | 5/A | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 1.2 | +4.098 | +4.303 | 5/E | AT0(?) | 151.013
Steel Assembly | RIGID_FRAME | 27.1 | +4.083 | +4.296 | 3-5/E | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 1.2 | +4.098 | +4.303 | 3/E | AT0(?) | 151.013
2 x Steel Assembly | RIGID_FRAME | 1.2 | +4.834 | +5.039 | 5/C | AT0(?) | 151.013
2 x Steel Assembly | RIGID_FRAME | 1.2 | +4.834 | +5.039 | 3/C | AT0(?) | 151.013
2 x Steel Assembly | RIGID_FRAME | 27.1 | +4.819 | +5.032 | 3-5/C | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +4.276 | +4.679 | 5/D | CO0(?) | 50.0001
2 x Steel Assembly | RIGID_FRAME | 0.6 | +4.276 | +4.679 | 3/D | CO0(?) | 50.0001
Steel Assembly | RIGID_FRAME | 27.1 | +4.458 | +4.671 | 3-5/D | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 1.2 | +4.098 | +4.303 | 5/A | AT0(?) | 151.013
Steel Assembly | RIGID_FRAME | 27.1 | +4.083 | +4.296 | 3-5/A | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 1.2 | +4.098 | +4.303 | 3/A | AT0(?) | 151.013
Steel Assembly | RIGID_FRAME | 0.6 | +4.276 | +4.679 | 5/B | CO0(?) | 50.0001
2 x Steel Assembly | RIGID_FRAME | 0.6 | +4.276 | +4.679 | 3/B | CO0(?) | 50.0001
Steel Assembly | RIGID_FRAME | 27.1 | +4.458 | +4.671 | 3-5/B | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 16.2 | +0.332 | +2.104 | 4-5/E | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 1.2 | +1.935 | +2.264 | 4/E | PL0(?) | 4
Steel Assembly | RIGID_FRAME | 16.2 | +2.107 | +3.867 | 3-4/E | A0(?) | 100
Steel Assembly | RIGID_FRAME | 2.9 | +0.344 | +0.494 | 5/E | A0(?) | 210
Steel Assembly | RIGID_FRAME | 2.9 | +3.704 | +3.854 | 3/E | A0(?) | 210
Steel Assembly | RIGID_FRAME | 33.1 | +0.332 | +3.867 | 3-5/E | A0(?) | 100
Steel Assembly | RIGID_FRAME | 1.2 | +3.909 | +3.956 | 5/E | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 1.2 | +3.909 | +3.956 | 3/E | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 27.1 | +3.956 | +4.056 | 3-5/E | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +2.054 | +2.104 | 5/E | CO0(?) | 50.0001
2 x Steel Assembly | RIGID_FRAME | 0.6 | +2.054 | +2.104 | 3/E | CO0(?) | 50.0001
Steel Assembly | RIGID_FRAME | 27.1 | +2.104 | +2.204 | 3-5/E | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +0.179 | +0.229 | 5/E | CO0(?) | 50.0001
2 x Steel Assembly | RIGID_FRAME | 0.6 | +0.179 | +0.229 | 3/E | CO0(?) | 50.0001
Steel Assembly | RIGID_FRAME | 27.1 | +0.229 | +0.329 | 3-5/E | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 2.9 | +0.344 | +0.494 | 3/E | A0(?) | 210
Steel Assembly | RIGID_FRAME | 2.9 | +3.704 | +3.854 | 5/E | A0(?) | 210
Steel Assembly | RIGID_FRAME | 16.2 | +0.332 | +2.104 | 4-5/A | A0(?) | 100
Steel Assembly | RIGID_FRAME | 16.2 | +2.107 | +3.867 | 3-4/A | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 1.2 | +1.935 | +2.264 | 4/A | PL0(?) | 4
Steel Assembly | RIGID_FRAME | 2.9 | +0.344 | +0.494 | 5/A | A0(?) | 210
Steel Assembly | RIGID_FRAME | 2.9 | +3.704 | +3.854 | 3/A | A0(?) | 210
Steel Assembly | RIGID_FRAME | 2.9 | +3.704 | +3.854 | 5/A | A0(?) | 210
Steel Assembly | RIGID_FRAME | 33.1 | +0.332 | +3.867 | 3-5/A | A0(?) | 100
Steel Assembly | RIGID_FRAME | 34.6 | -0.500 | +4.067 | 5/E | P0(?) | 100
Steel Assembly | RIGID_FRAME | 33.4 | -0.500 | +3.900 | 5/E | P0(?) | 100
Steel Assembly | RIGID_FRAME | 34.6 | -0.500 | +4.067 | 5/A | P0(?) | 100
Steel Assembly | RIGID_FRAME | 33.4 | -0.500 | +3.900 | 5/A | P0(?) | 100
Steel Assembly | RIGID_FRAME | 34.6 | -0.500 | +4.067 | 3/E | P0(?) | 100
Steel Assembly | RIGID_FRAME | 33.4 | -0.500 | +3.900 | 3/E | P0(?) | 100
Steel Assembly | RIGID_FRAME | 34.6 | -0.500 | +4.067 | 3/A | P0(?) | 100
Steel Assembly | RIGID_FRAME | 33.4 | -0.500 | +3.900 | 3/A | P0(?) | 100
Steel Assembly | RIGID_FRAME | 34.6 | -0.500 | +4.067 | 1/E | P0(?) | 100
Steel Assembly | RIGID_FRAME | 33.4 | -0.500 | +3.900 | 1/E | P0(?) | 100
Steel Assembly | RIGID_FRAME | 34.6 | -0.500 | +4.067 | 1/A | P0(?) | 100
Steel Assembly | RIGID_FRAME | 33.4 | -0.500 | +3.900 | 1/A | P0(?) | 100
Steel Assembly | RIGID_FRAME | 1.2 | +3.909 | +3.956 | 5/A | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 1.2 | +3.909 | +3.956 | 3/A | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 27.1 | +3.956 | +4.056 | 3-5/A | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +2.054 | +2.104 | 5/A | CO0(?) | 50.0001
2 x Steel Assembly | RIGID_FRAME | 0.6 | +2.054 | +2.104 | 3/A | CO0(?) | 50.0001
Steel Assembly | RIGID_FRAME | 27.1 | +2.104 | +2.204 | 3-5/A | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +0.179 | +0.229 | 5/A | CO0(?) | 50.0001
2 x Steel Assembly | RIGID_FRAME | 0.6 | +0.179 | +0.229 | 3/A | CO0(?) | 50.0001
Steel Assembly | RIGID_FRAME | 27.1 | +0.229 | +0.329 | 3-5/A | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 2.9 | +0.344 | +0.494 | 3/A | A0(?) | 210
Steel Assembly | RIGID_FRAME | 6.9 | +3.754 | +4.336 | 1/A | G0(?) | 4
Steel Assembly | RIGID_FRAME | 6.9 | +3.754 | +4.336 | 1/E | G0(?) | 4
2 x Steel Assembly | RIGID_FRAME | 2.9 | +4.592 | +4.823 | 3/C | A0(?) | 210
Steel Assembly | RIGID_FRAME | 18.3 | +3.905 | +4.457 | 3-4/A-B | A0(?) | 100
Steel Assembly | RIGID_FRAME | 1.2 | +4.433 | +4.487 | 4/B | PL0(?) | 4
Steel Assembly | RIGID_FRAME | 1.2 | +4.231 | +4.286 | 4/B | PL0(?) | 4
Steel Assembly | RIGID_FRAME | 2.9 | +3.899 | +4.130 | 3/A | A0(?) | 210
Steel Assembly | RIGID_FRAME | 18.4 | +4.261 | +4.815 | 4-5/B-C | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 2.9 | +4.592 | +4.823 | 5/C | A0(?) | 210
Steel Assembly | RIGID_FRAME | 37.3 | +3.903 | +4.814 | 3-5/A-C | A0(?) | 100
Steel Assembly | RIGID_FRAME | 36.5 | +3.905 | +4.836 | 5/A-C | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 38.1 | +4.077 | +5.039 | 5/A-C | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 2.9 | +3.895 | +4.126 | 5/A | A0(?) | 210
Steel Assembly | RIGID_FRAME | 6.9 | +3.754 | +4.336 | 5/A | G0(?) | 4
Steel Assembly | RIGID_FRAME | 36.5 | +3.905 | +4.836 | 3/A-C | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 38.1 | +4.077 | +5.039 | 3/A-C | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 6.9 | +3.754 | +4.336 | 3/A | G0(?) | 4
Steel Assembly | RIGID_FRAME | 8.3 | +4.595 | +5.045 | 1/C | G0(?) | 4
Steel Assembly | RIGID_FRAME | 8.3 | +4.595 | +5.045 | 3/C | G0(?) | 4
Steel Assembly | RIGID_FRAME | 8.3 | +4.595 | +5.045 | 5/C | G0(?) | 4
Steel Assembly | RIGID_FRAME | 18.4 | +4.261 | +4.815 | 4-5/C-D | A0(?) | 100
Steel Assembly | RIGID_FRAME | 18.3 | +3.905 | +4.457 | 3-4/D-E | A0(?) | 100
Steel Assembly | RIGID_FRAME | 1.2 | +4.433 | +4.487 | 4/D | PL0(?) | 4
Steel Assembly | RIGID_FRAME | 1.2 | +4.231 | +4.286 | 4/D | PL0(?) | 4
Steel Assembly | RIGID_FRAME | 2.9 | +3.899 | +4.130 | 3/E | A0(?) | 210
Steel Assembly | RIGID_FRAME | 2.9 | +3.895 | +4.126 | 5/E | A0(?) | 210
Steel Assembly | RIGID_FRAME | 37.3 | +3.903 | +4.814 | 3-5/C-E | A0(?) | 100
Steel Assembly | RIGID_FRAME | 36.5 | +3.905 | +4.836 | 5/C-E | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 38.1 | +4.077 | +5.039 | 5/C-E | AB0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 0.8 | +0.000 | +0.054 | 5/E | CO0(?) | 54
Steel Assembly | RIGID_FRAME | 6.9 | +3.754 | +4.336 | 5/E | G0(?) | 4
2 x Steel Assembly | RIGID_FRAME | 0.8 | +0.000 | +0.054 | 5/A | CO0(?) | 54
Steel Assembly | RIGID_FRAME | 27.7 | +4.083 | +4.296 | 1-3/E | PA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 27.7 | +4.819 | +5.032 | 1-3/C | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +4.276 | +4.679 | 1/D | CO0(?) | 50.0001
Steel Assembly | RIGID_FRAME | 27.7 | +4.458 | +4.671 | 1-3/D | PA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 1 | +4.874 | +4.985 | 3/C | AT0(?) | 254.983
2 x Steel Assembly | RIGID_FRAME | 1.2 | +4.834 | +5.039 | 1/C | AT0(?) | 151.013
Steel Assembly | RIGID_FRAME | 1 | +4.138 | +4.249 | 3/E | AT0(?) | 254.983
Steel Assembly | RIGID_FRAME | 1.2 | +4.098 | +4.303 | 3/E | AT0(?) | 150.993
Steel Assembly | RIGID_FRAME | 1.2 | +4.098 | +4.303 | 1/E | AT0(?) | 151.013
Steel Assembly | RIGID_FRAME | 36.5 | +3.905 | +4.836 | 3/C-E | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 38.1 | +4.077 | +5.039 | 3/C-E | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 36.5 | +3.905 | +4.836 | 1/C-E | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 38.1 | +4.077 | +5.039 | 1/C-E | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 1 | +4.514 | +4.624 | 3/B | AT0(?) | 254.983
Steel Assembly | RIGID_FRAME | 27.7 | +4.083 | +4.296 | 1-3/A | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +4.276 | +4.679 | 1/B | CO0(?) | 50.0001
Steel Assembly | RIGID_FRAME | 27.7 | +4.458 | +4.671 | 1-3/B | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +0.179 | +0.229 | 1/E | CO0(?) | 50.0001
Steel Assembly | RIGID_FRAME | 27.7 | +0.229 | +0.329 | 1-3/E | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 27.7 | +2.104 | +2.204 | 1-3/E | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +2.054 | +2.104 | 1/E | CO0(?) | 50.0001
Steel Assembly | RIGID_FRAME | 1.2 | +3.909 | +3.956 | 1/E | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 27.7 | +3.956 | +4.056 | 1-3/E | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 1.2 | +3.909 | +3.956 | 1/A | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 27.7 | +3.956 | +4.056 | 1-3/A | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +0.179 | +0.229 | 1/A | CO0(?) | 50.0001
Steel Assembly | RIGID_FRAME | 27.7 | +0.229 | +0.329 | 1-3/A | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 27.7 | +2.104 | +2.204 | 1-3/A | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +2.104 | +2.204 | 1/E | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.6 | +3.556 | +3.656 | 1/E | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.6 | +0.179 | +0.279 | 1/E | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.6 | +2.104 | +2.204 | 1/A | PLA0(?) | 2
2 x Steel Assembly | RIGID_FRAME | 0.8 | +0.000 | +0.054 | 3/E | CO0(?) | 54
Steel Assembly | RIGID_FRAME | 6.9 | +3.754 | +4.336 | 3/E | G0(?) | 4
2 x Steel Assembly | RIGID_FRAME | 0.8 | +0.000 | +0.054 | 3/A | CO0(?) | 54
2 x Steel Assembly | RIGID_FRAME | 0.8 | +0.000 | +0.054 | 1/E | CO0(?) | 54
Steel Assembly | RIGID_FRAME | 0.6 | +2.054 | +2.104 | 1/A | CO0(?) | 50.0001
Steel Assembly | RIGID_FRAME | 21.9 | +2.105 | +2.205 | 1/A-C | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 16.2 | +0.179 | +0.279 | 1/A-C | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 16.2 | +1.054 | +1.154 | 1/A-C | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +1.154 | +1.206 | 1/A-B | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 5.3 | +1.159 | +2.100 | 1/A-B | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +2.053 | +2.105 | 1/A-B | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.6 | +0.137 | +0.179 | 1/A | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.6 | +1.012 | +1.054 | 1/A | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.6 | +2.063 | +2.105 | 1/A | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.6 | +3.512 | +3.554 | 1/E | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 15.9 | +0.005 | +2.100 | 1/B-C | P0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 32 | +0.005 | +4.223 | 1/D | P0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 34.3 | +0.005 | +4.523 | 1/B-C | P0(?) | 100
Steel Assembly | RIGID_FRAME | 10.9 | +3.554 | +3.654 | 1/D-E | LS0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 0.6 | +2.063 | +2.105 | 1/B-C | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.6 | +3.512 | +3.554 | 1/A | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.6 | +0.137 | +0.179 | 1/E | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.6 | +2.062 | +2.104 | 1/E | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 36.5 | +3.905 | +4.836 | 1/A-C | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 38.1 | +4.077 | +5.039 | 1/A-C | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +0.137 | +0.179 | 1/D | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 10.9 | +0.179 | +0.279 | 1/D-E | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 10.9 | +2.104 | +2.204 | 1/D-E | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 21.9 | +3.554 | +3.654 | 1/A-C | LS0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 0.6 | +3.512 | +3.554 | 1/B-C | PL0(?) | 52
2 x Steel Assembly | RIGID_FRAME | 0.6 | +3.512 | +3.554 | 1/D | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.6 | +2.062 | +2.104 | 1/D | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 17 | +3.554 | +3.654 | 1/B-D | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +2.889 | +2.931 | 1/B-C | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.6 | +2.637 | +2.679 | 1/B-C | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.6 | +2.889 | +2.931 | 1/D | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.6 | +2.637 | +2.679 | 1/D | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 17 | +2.679 | +2.779 | 1/B-D | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 17 | +2.789 | +2.889 | 1/B-D | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.8 | +4.146 | +4.249 | 1/D | AT0(?) | 41.8379
Steel Assembly | RIGID_FRAME | 1 | +0.000 | +0.102 | 1/D | PL0(?) | 72
Steel Assembly | RIGID_FRAME | 0.8 | +4.446 | +4.549 | 1/B-C | AT0(?) | 41.8379
Steel Assembly | RIGID_FRAME | 1 | +0.000 | +0.102 | 1/B-C | PL0(?) | 72
Steel Assembly | RIGID_FRAME | 3.4 | +0.979 | +1.179 | 1/D-E | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 3.4 | +2.279 | +2.479 | 1/D-E | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 5.3 | +1.159 | +2.100 | 1/B | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.6 | +1.154 | +1.206 | 1/B | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.6 | +2.053 | +2.105 | 1/B | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.6 | +1.012 | +1.054 | 1/B-C | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.6 | +0.137 | +0.179 | 1/B-C | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 0.8 | +0.000 | +0.102 | 1/B-C | PL0(?) | 52
Steel Assembly | RIGID_FRAME | 1.2 | +1.332 | +1.379 | 1/A-B | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 0.6 | +3.556 | +3.656 | 1/A | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.6 | +0.179 | +0.279 | 1/A | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.8 | +0.000 | +0.054 | 1/<A | CO0(?) | 54
Steel Assembly | RIGID_FRAME | 0.8 | +0.000 | +0.054 | 5>/<A | CO0(?) | 54
2 x Steel Assembly | RIGID_FRAME | 0.8 | +0.000 | +0.054 | 1/A | CO0(?) | 54
Steel Assembly | RIGID_FRAME | 3.4 | +2.279 | +2.479 | 1/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 1 | +4.138 | +4.249 | 3/A | AT0(?) | 254.983
Steel Assembly | RIGID_FRAME | 1.2 | +4.098 | +4.303 | 3/A | AT0(?) | 150.993
Steel Assembly | RIGID_FRAME | 1.2 | +4.098 | +4.303 | 1/A | AT0(?) | 151.013
Steel Assembly | RIGID_FRAME | 1.2 | +2.632 | +2.679 | 1/A | AT0(?) | 170.003
Steel Assembly | RIGID_FRAME | 1.2 | +0.632 | +0.679 | 1/A | AT0(?) | 170.003

# IfcFooting: 450*130 (6)
In: Undefined
Description: 450*130; Material: MISCELLANEOUS/VERRE
Tekla Commun - Niveau bas: -0.550; Niveau haut: -0.000; Repère de pièce: S0(?); Repère d'assemblage: S0(?); Phase: 266; Classe: 8; Matériau: VERRE; Profil: 450*130; Nom: SEMELLE
Tekla Quantités - Poids: 81.4 kg; Volume: 0 m3; Surface supérieure totale: 0.1 m2; Surface par tonne: 9.3 m2; Surface nette: 0.8 m2; Hauteur: 450 mm; Largeur: 130 mm; Longueur: 550 mm
BaseQuantities - Length: 550 mm; OuterSurfaceArea: 0.755 m2; GrossSurfaceArea: 0.755 m2; CrossSectionArea: 0.0585 m2; NetVolume: 0.032175 m3; GrossVolume: 0.032175 m3; NetWeight: 81.4027 kg; GrossWeight: 81.4027 kg; Width: 130 mm; Height: 450 mm

# IfcFooting: 800*800 (6)
In: Undefined
Description: 800*800; Material: MISCELLANEOUS/VERRE
Tekla Commun - Niveau bas: -1.000; Niveau haut: -0.000; Repère de pièce: S0(?); Repère d'assemblage: S0(?); Phase: 266; Classe: 8; Matériau: VERRE; Profil: 800*800; Nom: SEMELLE
Tekla Quantités - Poids: 1619.2 kg; Volume: 0.6 m3; Surface supérieure totale: 0.6 m2; Surface par tonne: 2.8 m2; Surface nette: 4.5 m2; Hauteur: 800 mm; Largeur: 800 mm; Longueur: 1000 mm
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 4.48 m2; GrossSurfaceArea: 4.48 m2; CrossSectionArea: 0.64 m2; NetVolume: 0.64 m3; GrossVolume: 0.64 m3; NetWeight: 1619.2 kg; GrossWeight: 1619.2 kg; Width: 800 mm; Height: 800 mm

# IfcMechanicalFastener: Bolt assembly (4228)
In: Undefined
Material: 8.8
Tekla Boulons - Type rondelle: PLA-8.8; Type écrou: E-8.8; Trou oblong Y: 0 mm; Trou oblong X: 0 mm; Lieu Boulonnage: Montage; Standard: 8.8
Name | NominalDiameter (mm) = Diamètre rondelle (mm) = Diamètre (mm) | NominalLength (mm) | Quantité de rondelle | Nom rondelle | Quantité d'écrou | Nom écrou | Diamètre du trou (mm) | Quantité | Longueur (mm) | Nom
507 x Bolt assembly | 12 | 25 | 0 | RONDELLE-M12-PLA-8.8 | 2 | ECROU-M12-E-8.8 | 14 | 2 | 25 | M12*25
13 x Bolt assembly | 12 | 4.0002 | 0 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 2 | 4 | M12*25
169 x Bolt assembly | 12 | 1.5 | 0 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 2 | 1.5 | M12*25
126 x Bolt assembly | 12 | 1.5 | 0 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 1 | 1.5 | M12*25
5 x Bolt assembly | 24 | 4 | 0 | RONDELLE-M24-PLA-8.8 | 0 | ECROU-M24-E-8.8 | 26 | 1 | 4 | M24*50
2888 x Bolt assembly | 12 | 2 | 0 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 2 | 2 | M12*25
230 x Bolt assembly | 12 | 2 | 0 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 1 | 2 | M12*25
59 x Bolt assembly | 12 | 25 | 0 | RONDELLE-M12-PLA-8.8 | 4 | ECROU-M12-E-8.8 | 14 | 4 | 25 | M12*25
100 x Bolt assembly | 12 | 25 | 0 | RONDELLE-M12-PLA-8.8 | 1 | ECROU-M12-E-8.8 | 14 | 1 | 25 | M12*25
60 x Bolt assembly | 12 | 4 | 0 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 2 | 4 | M12*25
64 x Bolt assembly | 12 | 1.50019 | 0 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 1 | 1.5 | M12*25
4 x Bolt assembly | 12 | 4 | 0 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 1 | 4 | M12*25
2 x Bolt assembly | 12 | 4 | 0 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 4 | 4 | M12*25
Bolt assembly | 12 | 25 | 4 | RONDELLE-M12-PLA-8.8 | 4 | ECROU-M12-E-8.8 | 14 | 4 | 25 | M12*25

# IfcMember: SADEF-C+200X1.50 (6)
In: Undefined
Description: SADEF-C+200X1.50; Material: STEEL/Steel_Undefined
Tekla Commun - Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 6; Matériau: Steel_Undefined; Profil: SADEF-C+200X1.50; Nom: ARBA
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 151.5 m2; Hauteur: 200 mm; Largeur: 100 mm
Pset_MemberCommon - LoadBearing: yes; Reference: A0(?)
BaseQuantities - CrossSectionArea: 0.000723 m2
Name | Niveau bas | Niveau haut | Poids (kg) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
2 x ARBA | +0.332 | +2.104 | 16.2 | 3 | 2860 | 2860.01 | 2.45961 | 0.00216217 | 0.00206779 | 16.973 | 16.2321
2 x ARBA | +2.107 | +3.867 | 16.2 | 3 | 2839.4 | 2839.41 | 2.44189 | 0.00214659 | 0.00205289 | 16.8507 | 16.1152
2 x ARBA | +0.332 | +3.867 | 33.1 | 5.9 | 5840 | 5839.98 | 5.02238 | 0.00441502 | 0.0042223 | 34.6579 | 33.1451

# IfcPlate: PL2*100 (12)
In: Undefined
Description: PL2*100; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: PLA0(?); Repère d'assemblage: PLA0(?); Classe: 99; Matériau: S235JR; Profil: PL2*100; Nom: PLAT
Tekla Quantités - Poids: 0.6 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 130.6 m2; Surface nette: 0.1 m2; Hauteur: 100 mm; Largeur: 2 mm; Longueur: 400 mm
Pset_PlateCommon - LoadBearing: yes; Reference: PLA0(?)
BaseQuantities - Width: 100 mm; NetArea: 0.082 m2; GrossArea: 0.04 m2; CrossSectionArea: 0.000004 m2; NetVolume: 0.00008 m3; GrossVolume: 0.00008 m3
Name | Niveau bas | Niveau haut | Phase
4 x PLAT | +2.104 | +2.204 | 262
4 x PLAT | +3.556 | +3.656 | 247
4 x PLAT | +0.179 | +0.279 | 262

# IfcPlate: PL4*100 (8)
In: Undefined
Description: PL4*100; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: PL0(?); Repère d'assemblage: PL0(?); Classe: 99; Matériau: S235JR; Profil: PL4*100; Nom: PLAT
Tekla Quantités - Poids: 1.2 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 100 mm; Largeur: 4 mm
Pset_PlateCommon - LoadBearing: yes; Reference: PL0(?)
BaseQuantities - Width: 100 mm; CrossSectionArea: 0.000016 m2
Name | Niveau bas | Niveau haut | Phase | Surface par tonne (m2) | Longueur (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x PLAT | +1.935 | +2.264 | 265 | 66.8 | 420 | 0.0881704 | 0.042005 | 0.00016802
2 x PLAT | +4.433 | +4.487 | 264 | 67 | 370 | 0.0777704 | 0.037005 | 0.00014802
2 x PLAT | +4.231 | +4.286 | 264 | 67 | 370 | 0.0777704 | 0.037005 | 0.00014802

# IfcPlate: PL4*400 (6)
In: Undefined
Description: PL4*400; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +3.754; Niveau haut: +4.336; Repère de pièce: G0(?); Repère d'assemblage: G0(?); Phase: 261; Classe: 99; Matériau: S235JR; Profil: PL4*400; Nom: GOUSSET
Tekla Quantités - Poids: 6.9 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 64.8 m2; Surface nette: 0.4 m2; Hauteur: 400.2 mm; Largeur: 4 mm; Longueur: 582 mm
Pset_PlateCommon - LoadBearing: yes; Reference: G0(?)
BaseQuantities - Width: 400.158 mm; NetArea: 0.448656 m2; GrossArea: 0.232894 m2; CrossSectionArea: 0.000016 m2; NetVolume: 0.000882055 m3; GrossVolume: 0.000882055 m3

# IfcPlate: PL4*450 (3)
In: Undefined
Description: PL4*450; Material: STEEL/S235JR
Pset_PlateCommon - LoadBearing: yes; Reference: G0(?)
Tekla Commun - Niveau bas: +4.595; Niveau haut: +5.045; Repère de pièce: G0(?); Repère d'assemblage: G0(?); Phase: 260; Classe: 99; Matériau: S235JR; Profil: PL4*450; Nom: GOUSSET
Tekla Quantités - Poids: 8.3 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 64.8 m2; Surface nette: 0.4 m2; Hauteur: 450.1 mm; Largeur: 4 mm; Longueur: 682.4 mm
BaseQuantities - Width: 450.149 mm; NetArea: 0.537583 m2; GrossArea: 0.307168 m2; CrossSectionArea: 0.000016 m2; NetVolume: 0.00105873 m3; GrossVolume: 0.00105873 m3
